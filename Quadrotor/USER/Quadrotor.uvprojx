# Keil uVision project Quadrotor.uvprojx, settings and files
target quadrotor (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Quadrotor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\APPLICATION;..\CORE;..\DRIVER;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;.\Listings;.\Objects;..\USER;..\USMART;..\DRIVER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group APPLICATION
    ../APPLICATION/: ALG.c control.c telecontrol.c
  group DRIVER
    ../DRIVER/: led.c pwm_out.c time.c inv_mpu.c inv_mpu_dmp_motion_driver.c iic.c mpu6050.c hmc5883.c iicc.c bmp085.c usart3.c capture.c exit.c ov7670.c sccb.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
